# Keil uVision project myProject_MSP432P401R.uvprojx, settings and files
target MyTarget (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: myProject_MSP432P401R +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSP432P401R__
  c include: .\Library;.\Drivers;.\Library\third_party\CMSIS\Include;.\USER;.\CONTEST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Mode
    ./CONTEST/Mode/: Control_Car.c default.c LineTracing.c
  group Contest
    ./CONTEST/: Interface.c
  group Sourse
    ./USER/: main.c UART0.c SysTick_delay.c LED.c
  group Drivers
    ./Drivers/: OLED_12864.c FONT.c Beep.c Beep_song.c Remocon_Keys.c Motor.c Wireless.c TracingSensor.c
  group DriverLib
    ./Library/: msp432p4xx_driverlib.lib
  group System_StartUp
    ./StartUp_System/: system_msp432p401r.c startup_msp432p401r_uvision.s
